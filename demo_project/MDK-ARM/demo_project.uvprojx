# Keil uVision project demo_project.uvprojx, settings and files
target demo_project (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: demo_project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;          ../Drivers/CMSIS/Include;        ../Middlewares/ST/AI/Inc;   ../Middlewares/ST/Application/Validation/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: network.c network_data.c main.c gpio.c crc.c app_x-cube-ai.c sys.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ..//: network_generate_report.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime500_CM4_Keil.lib
  group Middlewares/X-CUBE-AI/Artificial Intelligence/Application/Validation
    ../Middlewares/ST/Application/Validation/Src/: aiPbMgr.c aiTestUtility.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
software components: CMSIS:CORE 4.3.0
